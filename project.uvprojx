# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32h7xx (ARM-ADS)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread-stm32h7xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, LFS_CONFIG=lfs_config.h, RT_USING_ARM_LIBC, STM32H743xx
  c include: applications;.;drivers;drivers\touch;.;Libraries\CMSIS\Device\ST\STM32H7xx\Include;Libraries\CMSIS\Include;Libraries\STM32H7xx_HAL_Driver\Inc;packages\gui_engine-latest\include;packages\gui_engine-latest\libraries\lodepng;packages\gui_engine-latest\src;packages\gui_engine-latest\example;packages\littlefs-v0.9.0;..\rt-thread\include;..\rt-thread\libcpu\arm\cortex-m7;..\rt-thread\libcpu\arm\common;..\rt-thread\components\dfs\include;..\rt-thread\components\dfs\filesystems\devfs;..\rt-thread\components\dfs\filesystems\elmfat;..\rt-thread\components\dfs\filesystems\romfs;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\usb\usbdevice;..\rt-thread\components\finsh;..\rt-thread\components\libc\compilers\armlibc;..\rt-thread\components\libc\compilers\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\rtthread-stm32h7xx.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: lcd_init.c main.c
  group Drivers
    drivers/: board.c drv_mpu.c drv_cache.c drv_romfs.c drv_usart.c drv_usbd.c drv_sdram.c drv_ltdc.c drv_gpio.c drv_i2c.c
  group touch
    drivers/touch/: drv_touch.c drv_touch_ft.c drv_touch_gt9xx.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group STM32H7xx_HAL_Driver
    Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group GuiEngine
    packages/gui_engine-latest/libraries/lodepng/: lodepng.c
    packages/gui_engine-latest/src/: asc12font.c asc16font.c blit.c box.c color.c container.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c dc_rotozoom.c dc_trans.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c gb2312.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_jpg.c image_png.c image_xpm.c matrix.c mouse.c region.c rtgui_app.c rtgui_driver.c rtgui_object.c rtgui_system.c server.c title.c topwin.c widget.c window.c
  group gui_demo
    packages/gui_engine-latest/example/: gui_demo.c resources.c
  group littlefs
    packages/littlefs-v0.9.0/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group Kernel
    ../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M7
    ../rt-thread/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group DeviceDrivers
    ../rt-thread/components/drivers/cputime/: cputime.c cputime_cortexm.c
    ../rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group rt_usbd
    ../rt-thread/components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group finsh
    ../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../rt-thread/components/libc/compilers/common/: gmtime_r.c
